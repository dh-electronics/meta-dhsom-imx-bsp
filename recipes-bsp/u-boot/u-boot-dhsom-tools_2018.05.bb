require u-boot-dhsom-common_2018.05.inc
require recipes-bsp/u-boot/u-boot-mainline-tools.inc

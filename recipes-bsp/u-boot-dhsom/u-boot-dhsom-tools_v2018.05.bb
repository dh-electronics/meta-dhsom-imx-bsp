require u-boot-dhsom-common_v2018.05.inc
require recipes-bsp/u-boot/u-boot-mainline-tools.inc


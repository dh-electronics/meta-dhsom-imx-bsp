PACKAGECONFIG_remove_dh-imx6-dhsom = "etnaviv"

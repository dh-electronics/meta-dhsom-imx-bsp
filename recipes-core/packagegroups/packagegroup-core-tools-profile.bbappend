LTTNGTOOLS:remove:dh-imx-dhsom = "lttng-modules"
LTTNGMODULES:dh-imx-dhsom = ""

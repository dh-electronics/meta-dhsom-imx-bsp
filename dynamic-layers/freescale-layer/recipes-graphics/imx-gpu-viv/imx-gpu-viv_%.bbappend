FILESEXTRAPATHS:prepend:mx8mp-nxp-bsp := "${THISDIR}/files:"
PACKAGES_OPENVX:mx8mp-nxp-bsp = "libopenvx-imx libopenvx-imx-dev"
